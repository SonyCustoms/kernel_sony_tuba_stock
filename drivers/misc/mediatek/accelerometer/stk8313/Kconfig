## drivers/misc/mediatek/accelerometer/stk8313/Kconfig
```kconfig
config MTK_STK8313
        bool "STK8313 for Mediatek package"
        default y
```
